// open source if you improve this please share with me and others
int min_sweep = 0;
int max_sweep = 180;
int min_tilt = 0;
int max_tilt = 180;
int sweep_rate = 40;

float correct;
int k = 0;

// ----------------------------------U/S Ranging-----------------------------------------
#include <NewPing.h>
#define TRIGGER_PIN 3 // Arduino pin tied to trigger pin on ping sensor.
#define ECHO_PIN 4 // Arduino pin tied to echo pin on ping sensor.
#define MAX_DISTANCE 400 // Maximum distance we want to ping for (in centimeters). Maximum sensor distance is rated at 400-500cm.
// Includes the Servo library
#include <Servo.h>.
// Defines Tirg and Echo pins of the Ultrasonic Sensor
const int trigPin = 3;
const int echoPin = 4;
// Variables for the duration and the distance
long duration;
int distance;
Servo Pan_Servo; // Creates a servo object for controlling the servo motor
Servo Tilt_Servo; // Creates a servo object for controlling the servo motor
int j = 45;
NewPing sonar(TRIGGER_PIN, ECHO_PIN, MAX_DISTANCE); // NewPing setup of pins and maximum distance.
unsigned int pingSpeed = 50; // How frequently are we going to send out a ping (in milliseconds). 50ms would be 20 times a second.
unsigned long pingTimer; // Holds the next ping time.
// ---------------------------------------------------------------------------
char val; // Data received from the serial port
int ledPin = 13; // Set the pin to digital I/O 13
boolean ledState = LOW; //to toggle our LED
boolean R_State = LOW; //to toggle our LED
boolean T_State = LOW; //to toggle our LED
boolean B_State = LOW; //to toggle our LED
boolean F_State = LOW; //to toggle our LED




void setup()
{
  // ----------------------------------U/S Ranging-----------------------------------------
  pingTimer = millis(); // Start now.
  // ---------------------------------------------------------------------------
  pinMode(trigPin, OUTPUT); // Sets the trigPin as an Output
  pinMode(echoPin, INPUT); // Sets the echoPin as an Input
  //Serial.begin(115200);
  Pan_Servo.attach(5); // Defines on which pin is the servo motor attached
  Tilt_Servo.attach(6); // Defines on which pin is the servo motor attached
  //Tilt_Servo.write(45);
  pinMode(ledPin, OUTPUT); // Set pin as OUTPUT
  pinMode(ledPin, OUTPUT); // Set pin as OUTPUT
  //initialize serial communications at a 9600 baud rate
  Serial.begin(115200);
  //establishContact(); // send a byte to establish contact until receiver responds
  /////////////////////////////////////IMU///////////////////////////////////

  // join I2C bus

}
void loop()
{//format to serial port : angle,distance.
  
  // rotates the servo motor from 15 to 165 degrees
  for (int i = min_sweep; i <= max_sweep; i++) {
    Pan_Servo.write(i);
    //IMU_Data();
    Tilt_Servo.write(j);
    delay(sweep_rate);
    buttons();
    //distance = calculateDistance();// Calls a function for calculating the distance measured by the Ultrasonic sensor for each degree
    get_US_range();
    Serial.print(i); // Sends the current degree into the Serial Port
    Serial.print(","); // Sends addition character right next to the previous value needed later in the Processing IDE for indexing
    Serial.print(sonar.ping_result / US_ROUNDTRIP_CM); // Sends the distance value into the Serial Port
    Serial.print("."); // Sends addition character right next to the previous value needed later in the Processing IDE for indexing
  }
  // Repeats the previous lines from 165 to 15 degrees
  for (int i = max_sweep; i > min_sweep; i--) {
    Pan_Servo.write(i);
    //IMU_Data();
    Tilt_Servo.write(j);

    delay(sweep_rate);
    buttons();
    //distance = calculateDistance();
    get_US_range();
    Serial.print(i);
    Serial.print(",");
    Serial.print(sonar.ping_result / US_ROUNDTRIP_CM);//Ranging data
    Serial.print(".");
  }
  //Serial.println("Hello, world!"); //send back a hello world
  delay(50);
  // }
}
void buttons() {
  //establishContact(); // send a byte to establish contact until receiver responds
  if (Serial.available() > 0) { // If data is available to read,
    val = Serial.read(); // read it and store it in val
    /////////----------------------
    if (val == 'r') //if we get a r Fast Sweep
    { sweep_rate = 7;
      // R_State = !R_State; //flip the ledState
      // digitalWrite(13, R_State);
    }
    /////////----------------------
    if (val == 't') //if we get a t
    { sweep_rate = 20;
      //T_State = !T_State; //flip the ledState Quick Sweep
      //digitalWrite(13, T_State);
    }
    /////////----------------------
    if (val == 'b') //if we get at b Medium Sweep
    { sweep_rate = 40;
      // B_State = !B_State; //flip the ledState
      // digitalWrite(13, B_State);
    }
    /////////----------------------
    if (val == 'e') //if we get a e Slow Sweep
    { sweep_rate = 80;
      //F_State = !F_State; //flip the ledState
      //digitalWrite(13, F_State);
    }
    /////////----------------------
    if (val == 'y') //if we get a y Full Sweep
    {
      min_sweep = 0;
      max_sweep = 180;
      // R_State = !R_State; //flip the ledState
      // digitalWrite(13, R_State);
    }
    /////////----------------------
    if (val == 'u') //if we get a u Wide Sweep
    {
      min_sweep = 30;
      max_sweep = 150;
      //T_State = !T_State; //flip the ledState
      //digitalWrite(13, T_State);
    }
    /////////----------------------
    if (val == 'i') //if we get at i Narrow Sweep
    {
      min_sweep = 60;
      max_sweep = 120;
    }
    /////////----------------------
    if (val == 'o') //if we get a o Steer Sweep
    {
      min_sweep = 70;
      max_sweep = 110;
    }
    /////////----------------------
    if (val == 'p') //if we get a p Beam Sweep
    {
      min_sweep = 84;
      max_sweep = 96;
    }
    /////////----------------------
    if (val == 's') //if we get a s Stop Sweep
    {
      min_sweep = 90;
      max_sweep = 90;
      sweep_rate = 10;
    }
    /////////----------------------
    if (val == 'd') //if we get a p Beam Sweep
    {
      j = j - 1;



    }
    /////////----------------------
    if (val == 'f') //if we get a s Stop Sweep
    {
      j = j  +1;
    }
    /////////----------------------
    delay(100);
  }
  else {
  }
}
////////////////////////////////////////////////
void establishContact() {
  while (Serial.available() <= 0) {
    Serial.print("A"); // send a capital A
    //aSerial.println("."); // send a capital A
    delay(300);
  }
}
///////////////////////////////////////////////////////////////////
void get_US_range() {
  // Notice how there's no delays in this sketch to allow you to do other processing in-line while doing distance pings.
  if (millis() >= pingTimer) { // pingSpeed milliseconds since last ping, do another ping.
    pingTimer += pingSpeed; // Set the next ping time.
    sonar.ping_timer(echoCheck); // Send out the ping, calls "echoCheck" function every 24uS where you can check the ping status.
  }
  // Do other stuff here, really. Think of it as multi-tasking.
}
void echoCheck() { // Timer2 interrupt calls this function every 24uS where you can check the ping status.
  // Don't do anything here!
  if (sonar.check_timer()) { // This is how you check to see if the ping was received.

  }

}

///////////////////////////////////////////////////////////////
